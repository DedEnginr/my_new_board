## custom/my_board_2/my_board_2_defconfig
```kconfig
# SPDX-License-Identifier: Apache-2.0


CONFIG_SYS_CLOCK_HW_CYCLES_PER_SEC=25000000
```
